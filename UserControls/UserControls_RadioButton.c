/*
    Adaptive Operating System
    Copyright (C) 2014  Contemplator (Ivan Zaikov)

    This program is free software: you can redistribute it and/or modify
    it under the terms of the GNU General Public License as published by
    the Free Software Foundation, either version 3 of the License, or
    (at your option) any later version.

    This program is distributed in the hope that it will be useful,
    but WITHOUT ANY WARRANTY; without even the implied warranty of
    MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
    GNU General Public License for more details.

    You should have received a copy of the GNU General Public License
    along with this program.  If not, see <http://www.gnu.org/licenses/>.
*/

#include <UserControls_RadioButton.h>

static UserControls_RadioButton_t _controls[UC_MAX_RADIOBUTTON];
static uint8_t _maxNumb = 0;
static int8_t _lastNumb[UC_MAX_RADIOBUTTON_GROUP];
static uint8_t iterator;

void UserControls_RadioButton_Add(int x, int y, char* text, uint8_t group, bool pressed)
{
	_controls[_maxNumb].x = x;
	_controls[_maxNumb].y = y;
	_controls[_maxNumb].text = text;
	_controls[_maxNumb].pressed = pressed;
	_controls[_maxNumb].group = group;
	if (group >= UC_MAX_RADIOBUTTON_GROUP) 
	{
		MessageBox_Show("Fatal Error", "Number of RadioButton group is wrong (Add function)", true, false);
		return;
	}
	if (pressed) _lastNumb[group] = _maxNumb;
	UserControls_RadioButton_Draw(x, y, text, pressed);
	_maxNumb++;
	if (_maxNumb >= UC_MAX_RADIOBUTTON) 
	{
		MessageBox_Show("RadioButtons count overflow", "Fatal Error", true, false);
		_maxNumb = UC_MAX_RADIOBUTTON-1;
	}
}

void UserControls_RadioButton_Clear(void)
{
	_maxNumb = 0;
}

void UserControls_RadioButton_Set(int num, int group)
{
	if (group >= UC_MAX_RADIOBUTTON_GROUP) 
	{
		MessageBox_Show("Fatal Error", "Number of RadioButton group is wrong (Set function)", true, false);
		return;
	}
	_lastNumb[group] = num;
}

static int _getNum(int x, int y)
{
	for (iterator = 0; iterator < _maxNumb; iterator++)
	{
		if (x > _controls[iterator].x && 
			x < _controls[iterator].x + 20 + strlen(_controls[iterator].text)*6 &&
			y > _controls[iterator].y && 
			y < _controls[iterator].y + 13)
		{
			return iterator;
		}
	}
	return -1;
}

static void _refresh(void)
{
	for (iterator = 0; iterator < _maxNumb; iterator++)
	{
		_controls[iterator].pressed = (iterator == _lastNumb[_controls[iterator].group]);
		UserControls_RadioButton_Draw(_controls[iterator].x,
									  _controls[iterator].y,
									  _controls[iterator].text,
									  _controls[iterator].pressed);
	}
}

int8_t UserControls_RadioButton_Handle(int x, int y, int pressed)
{
	if (pressed)
	{
		int8_t _sNum = _getNum(x,y); 
		if (_sNum != _lastNumb[_controls[_sNum].group] && _sNum != -1)
		{
			_lastNumb[_controls[_sNum].group] = _sNum;
			_refresh();
		}
		return _sNum;
	}
	return -1;
}

void UserControls_RadioButton_Draw(int x, int y, char* text, bool pressed)
{
	GUI_DrawImage(((pressed) ? Radio2 : Radio1), x, y, 13, 13);
	GUI_Text(x + 20, y+3, (uint8_t*)text, White, Black);
}

char* UserControls_RadioButton_GetTextFromIndex(int8_t ind)
{
	if (ind != -1 && ind < _maxNumb) 
	{
		return _controls[ind].text;
	}
	else
	{
		return 0;
	}
}

int UserControls_RadioButton_GetDigitFromIndex(int8_t ind)
{
	if (ind != -1 && ind < _maxNumb) 
	{
		return atoi(_controls[ind].text);
	}
	else
	{
		return -1;
	}
}

// image 13 x 13 (W x H)
const unsigned int Radio1[]={
0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xFFFF, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xFFFF, 0xB5B6, 0xB5B6, 0xB5B6, 0xFFFF, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 
0x0000, 0xB5B6, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xB5B6, 0x0000, 
0x0000, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0x0000, 
0xB5B6, 0xFFFF, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xFFFF, 0xB5B6, 
0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 
0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 
0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 
0xB5B6, 0xFFFF, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xFFFF, 0xB5B6, 
0x0000, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0x0000, 
0x0000, 0xB5B6, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xB5B6, 0x0000, 
0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xFFFF, 0xB5B6, 0xB5B6, 0xB5B6, 0xFFFF, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xFFFF, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000  
};

// image 13 x 13 (W x H)
const unsigned int Radio2[]={
0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xFFFF, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 
0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xFFFF, 0xB5B6, 0xB5B6, 0xB5B6, 0xFFFF, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 
0x0000, 0xB5B6, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xB5B6, 0x0000, 
0x0000, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x07E0, 0x07E0, 0x07E0, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0x0000, 
0xB5B6, 0xFFFF, 0x0000, 0x0000, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x0000, 0x0000, 0xFFFF, 0xB5B6, 
0xFFFF, 0xB5B6, 0x0000, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x0000, 0xB5B6, 0xFFFF, 
0xFFFF, 0xB5B6, 0x0000, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x0000, 0xB5B6, 0xFFFF, 
0xFFFF, 0xB5B6, 0x0000, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x0000, 0xB5B6, 0xFFFF, 
0xB5B6, 0xFFFF, 0x0000, 0x0000, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x07E0, 0x0000, 0x0000, 0xFFFF, 0xB5B6, 
0x0000, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x07E0, 0x07E0, 0x07E0, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0x0000, 
0x0000, 0xB5B6, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xB5B6, 0x0000, 
0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xFFFF, 0xB5B6, 0xB5B6, 0xB5B6, 0xFFFF, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 
0x0000, 0x0000, 0x0000, 0x0000, 0xB5B6, 0xFFFF, 0xFFFF, 0xFFFF, 0xB5B6, 0x0000, 0x0000, 0x0000, 0x0000  
};

/******************* (C) Copyright (C) 2014  Contemplator (Ivan Zaikov) *****END OF FILE****/
