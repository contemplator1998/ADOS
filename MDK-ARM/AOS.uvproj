# Keil uVision project AOS.uvproj, settings and files
target AOS (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: AOS +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F4XX
  c include: ..\;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32F4-Discovery;..\LCD;..\LCD\Drivers\inc;..\SDIO;..\FATFS\inc;..\UserControls;..\Flash;..\TouchPanel;..\Core;..\SD;..\FormManager;..\PWR;..\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xaff0
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c misc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group LCD
    ../LCD/: AsciiLib.c LCD.c
    ../LCD/Drivers/src/: ILI9481.c
  group SD Card
    ../SDIO/: stm324xg_eval.c stm324xg_eval_sdio_sd.c
    ../FATFS/src/: diskio.c ff.c fattime.c
    ../SD/: SDUser.c
    ../FATFS/src/option/: ccsbcs.c
  group UserControls
    ../UserControls/: UserControls_Button.c UserControls_CheckBox.c UserControls_ListBox.c UserControls_MessageBox.c UserControls_RadioButton.c UserControls_ValueRegulator.c
  group Flash
    ../Flash/: flash.c
  group TouchPanel
    ../TouchPanel/: TouchPanel.c
  group Core
    ../Core/: Core.c
  group FormManager
    ../FormManager/: FormManager.c
  group PWR
    ../PWR/: PWR.c
  group RTC
    ../RTC/: RTC_Time.c
